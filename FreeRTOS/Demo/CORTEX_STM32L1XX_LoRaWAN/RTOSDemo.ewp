# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_MD; STM32L151xB; USE_STDPERIPH_DRIVER; TRACKERBOARD; REGION_US915; HAL_IWDG_MODULE_ENABLED; LORA_HF_BOARD
  ICCARM.CCIncludePath2: include; ST_Code\STM32L-DISCOVERY; ST_Code\libraries\STM32L1xx_StdPeriph_Driver\inc; ST_Code\libraries\STMTouch_Driver\inc; ST_Code\libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; ..\Common\include; LoRaWAN\mac; LoRaWAN\mac\region; LoRaWAN\portable; LoRaWAN\radio; LoRaWAN\radio\sx1276; LoRaWAN\soft-se; LoRaWAN\system; ST_Code\STM32L1xx_HAL_Driver\Inc; LoRaWAN\utilities; ST_Code\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: include
  OBJCOPY.OOCOutputFile: RTOSDemo.hex
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    include/: FreeRTOSConfig.h
    ./: main_lorawan.c
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Source/Portable
    ../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS Source/Portable/IAR/ARM_CM3
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group LoRaWAN/mac
    LoRaWAN/mac/: LoRaMac.c LoRaMac.h LoRaMacAdr.c LoRaMacAdr.h LoRaMacClassB.c LoRaMacClassB.h LoRaMacClassBConfig.h LoRaMacCommands.c LoRaMacCommands.h LoRaMacConfirmQueue.c LoRaMacConfirmQueue.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacHeaderTypes.h LoRaMacMessageTypes.h LoRaMacParser.c LoRaMacParser.h LoRaMacSerializer.c LoRaMacSerializer.h LoRaMacTest.h LoRaMacTypes.h secure-element.h
  group LoRaWAN/mac/region
    LoRaWAN/mac/region/: Region.c Region.h RegionAS923.c RegionAS923.h RegionAU915.c RegionAU915.h RegionCN470.c RegionCN470.h RegionCN779.c RegionCN779.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionIN865.c RegionIN865.h RegionKR920.c RegionKR920.h RegionRU864.c RegionRU864.h RegionUS915.c RegionUS915.h
  group LoRaWAN/portable
    LoRaWAN/portable/: adc-board.c adc-board.h board.c board.h delay-board.c delay-board.h eeprom-board.c eeprom-board.h gpio-board.c gpio-board.h gps-board.c gps-board.h i2c-board.c i2c-board.h pinName-board.h pinName-ioe.h rtc-board.c rtc-board.h spi-board.c spi-board.h sx1276-board.c sx1276-board.h timer-board.c timer-board.h uart-board.c uart-board.h
  group LoRaWAN/radio
    LoRaWAN/radio/: radio.h
  group LoRaWAN/radio/sx1276
    LoRaWAN/radio/sx1276/: sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group LoRaWAN/soft-se
    LoRaWAN/soft-se/: aes.c aes.h cmac.c cmac.h se-identity.h soft-se-hal.c soft-se-hal.h soft-se.c
  group LoRaWAN/system
    LoRaWAN/system/: adc.c adc.h delay.c delay.h eeprom.c eeprom.h fifo.c fifo.h gpio.c gpio.h gps.c gps.h i2c.c i2c.h nvmm.c nvmm.h serial.h spi.h systime.c systime.h timer.c timer.h uart.c uart.h
  group LoRaWAN/utilities
    LoRaWAN/utilities/: cJSON.c cJSON.h utilities.c utilities.h
  group ST_Code/cmsis
    ST_Code/CMSIS/: mxconstants.h stm32l151xb.h stm32l151xba.h stm32l1xx.h stm32l1xx_hal_conf.h system_stm32l1xx.c system_stm32l1xx.h
  group ST_Code/hal
    ST_Code/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c dynamic.c GenQTest.c PollQ.c recmutex.c semtest.c
  group System
    System/: startup_stm32l151xb.s
